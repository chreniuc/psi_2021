# Keil uVision project mbeGateF429.uvprojx, settings and files
target mbeGateUsb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbeGateF429
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\mbeHeader
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./mbeMain/: main.c
  group Threads
    ./mbeThreads/: mbeThreadCyclea.c mbeThreadDispatcherForServera.c mbeThreadDispatcherForLOGa.c mbeThtradLLOGtoDiska.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:CDC 6.14.1, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:USART 2.13, CMSIS Driver:USB Device:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
